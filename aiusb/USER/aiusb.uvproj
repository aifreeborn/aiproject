# Keil uVision project aiusb.uvproj, settings and files
target aiusb (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: aiusb +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\CORE;..\CORE\UART;..\HRDWARE\KEYS;..\HRDWARE\LEDS;..\HRDWARE\USB;..\HRDWARE\PDIUSBD12
  group USER
    ./: STARTUP.A51 main.c
  group CORE
    ../CORE/UART/: aiuart.c
  group HARDWARE
    ../HRDWARE/KEYS/: aikeys.c
    ../HRDWARE/LEDS/: aileds.c
    ../HRDWARE/USB/: aiusb.c
    ../HRDWARE/PDIUSBD12/: aipdiusbd12.c
