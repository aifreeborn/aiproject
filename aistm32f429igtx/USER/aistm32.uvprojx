# Keil uVision project aistm32.uvprojx, settings and files
target aistm32 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: aistm32 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F429xx,USE_DMP,MPL_LOG_NDEBUG=1,EMPL,MPU9250,EMPL_TARGET_STM32F4
  c include: ..\CORE\INC;..\SYSTEM\aidelay;..\SYSTEM\aigpio;..\SYSTEM\aisys;..\SYSTEM\aiusart;..\HARDWARE\LED;..\HARDWARE;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\HARDWARE\IWDG;..\HARDWARE\WWDG;..\HARDWARE\TIMER;..\HARDWARE\TOUCHPAD;..\HARDWARE\SDRAM;..\HARDWARE\LTDC;..\USMART;..\HARDWARE\RTC;..\HARDWARE\RNG;..\HARDWARE\WKUP;..\HARDWARE\ADC;..\HARDWARE\DAC;..\HARDWARE\DMA;..\HARDWARE\IIC;..\HARDWARE\AT24CXX;..\HARDWARE\PCF8574;..\HARDWARE\AP3216C;..\HARDWARE\SPI;..\HARDWARE\W25QXX;..\HARDWARE\CAN;..\HARDWARE\TOUCHPANEL;..\HARDWARE\REMOTE;..\HARDWARE\DHT11;..\HARDWARE\MPU9250;..\HARDWARE\MPU9250\MPL\mpl;..\HARDWARE\MPU9250\MPL\mllite;..\HARDWARE\MPU9250\MPL\eMPL-hal;..\HARDWARE\MPU9250\MPL\driver\eMPL;..\HARDWARE\MPU9250\MPL\driver\include;..\HARDWARE\MPU9250\MPL\driver\stm32L
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c
  group CORE
    ../CORE/: startup_stm32f429xx.s
  group SYSTEM
    ../SYSTEM/aidelay/: aidelay.c
    ../SYSTEM/aigpio/: aigpio.c
    ../SYSTEM/aisys/: aisys.c
    ../SYSTEM/aiusart/: aiusart.c
  group HARDWARE
    ../HARDWARE/LED/: ailed.c
    ../HARDWARE/KEY/: aikey.c
    ../HARDWARE/SDRAM/: aiwm9825g6kh.c
    ../HARDWARE/LTDC/: ailtdc.c ailcd.c
    ../HARDWARE/TOUCHPANEL/: aictpi2c.c aift5206.c aitouch.c
    ../HARDWARE/SPI/: aispi.c
    ../HARDWARE/PCF8574/: aipcf8574.c
    ../HARDWARE/IIC/: aii2c.c
    ../HARDWARE/MPU9250/: aimpu9250.c
  group MPL
    ../HARDWARE/MPU9250/MPL/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/MPU9250/MPL/driver/stm32L/: log_stm32.c
    ../HARDWARE/MPU9250/MPL/eMPL-hal/: eMPL_outputs.c
    ../HARDWARE/MPU9250/MPL/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
    ../HARDWARE/MPU9250/MPL/mpl/: libmpllib.lib
  group README
    ../README/: README
